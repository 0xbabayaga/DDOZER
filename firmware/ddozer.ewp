# IAR project ddozer.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: src\; src\stm8\; src\stm8\inc\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ddozer.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: ddozer.out
  group (top)
    src/: main.c
  group base
    src/base/: types.h
  group core
    src/core/: menu.c menu.h strings.h task.c task.h
  group device
    src/drivers/: ascii.c ascii.h ssd1306.c ssd1306.h
    src/device/: cpuinit.c cpuinit.h delay_us.c delay_us.h device.c device.h device_types.h eeprom.c eeprom.h encoder.c encoder.h timers.c timers.h utility.c utility.h
  group drivers
    src/drivers/: drv8825.c drv8825.h ds1307.c ds1307.h
